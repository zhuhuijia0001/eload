# Keil uVision project eloadlpc1754.uvproj, settings and files
target eLoadMaster (ARM-ADS)
  device: LPC1754 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IRAM2(0x2007C000-0x2007FFFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: eload_1754_main
  AfterMake: $KARM\BIN\ElfDwT.exe "$L@L.axf"
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1
  c define: __BUILD_WITH_EXAMPLE__
  c include: .\app;.\bsp;.\cfg;.\dev;.\fs;.\menu;.\util;.\thread;.\rtos\include;.\LPC17XX_Lib\Driver\include;.\LPC17XX_Lib\CMSIS\CoreSupport;.\LPC17XX_Lib\CMSIS\DeviceSupport
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group app
    ./app/: application.c platform.c startup.c type.h platform.h trace.h parameter.c parameter.h packet.c packet.h protocol.h global.c global.h
  group bsp
    ./bsp/: beeper.h board.h gpio_map.h key.h lcd.h PinDefine.h beeper.c board.c key.c lcd.c eeprom.c eeprom.h key_define.h beeper_define.h led_define.h led.h led.c slave_com.h slave_com.c spi.h spi.c W25QXX.c W25QXX.h
  group rt-thread
    ./rtos/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group rt-thread-ports
    ./cpuport/arm/cortex-m3/: cpuport.c context_rvds.S
    ./cpuport/arm/common/: backtrace.c div0.c showmem.c
  group LPC17XX_CSP_CMSIS_Device
    ./LPC17XX_Lib/CMSIS/DeviceSupport/: system_LPC17xx.c system_LPC17xx.h LPC17xx.h
    ./LPC17XX_Lib/CMSIS/DeviceSupport/startup/arm/: startup_LPC17xx.s
  group LPC17XX_CSP_CMSIS_Core
    ./LPC17XX_Lib/CMSIS/CoreSupport/: core_cm3.h core_cmFunc.h core_cmInstr.h core_cm3.c
  group LPC17XX_CSP_Driver
    ./LPC17XX_Lib/Driver/source/: debug_frmwrk.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_iap.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c
  group cfg
    ./cfg/: lpc17xx_libcfg.h rtconfig.h
  group dev
    ./dev/: console_uart.h console_uart.c dev_eeprom.h dev_eeprom.c dev_key.h dev_key.c dev_beeper.h dev_beeper.c dev_led.h dev_led.c dev_lcd.h dev_lcd.c dev_slave_uart.c dev_slave_uart.h
  group menu
    ./menu/: menu.c menu.h menu_op.h menu_main.c draw.h draw.c menu_string.h menu_cv_mode.c menu_cc_mode.c menu_cr_mode.c menu_welcome.c menu_cc_setting.c menu_cv_setting.c menu_cr_setting.c menu_over_current_setting.c menu_short_setting.c menu_discharge_setting.c menu_factory_mode.c menu_adjust.c menu_life.c menu_phone_setting.c menu_privilege.c menu_empty_load_setting.c menu_dp_dn_divide_mode_setting.c menu_dp_dn_resist_mode_setting.c menu_dp_dn_short_mode_setting.c menu_synth_test_setting.c menu_synth_test.c menu_channel_setting.c
  group util
    ./util/: utility.h utility.c
  group thread
    ./thread/: msg_thread.c msg_thread.h com_thread.h com_thread.c
  group fs
    ./fs/: dfs.c dfs_elm.c dfs_file.c dfs_fs.c ff.c dfs.h dfs_def.h dfs_elm.h dfs_file.h dfs_fs.h dfs_init.h diskio.h ff.h ffconf.h integer.h dfs_posix.c dfs_posix.h

# Keil uVision project eload_lpc1754slaver.uvproj, settings and files
target eLoadSlaver (ARM-ADS)
  device: LPC1754 NXP
  cpu: IRAM(0x10000000-0x10003FFF) IRAM2(0x2007C000-0x2007FFFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: eload_lpc1754slaver
  AfterMake: $KARM\BIN\ElfDwT.exe "$L@L.axf"
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1
  c define: __BUILD_WITH_EXAMPLE__
  c include: .\app;.\bsp;.\dev;.\cfg;.\thread;.\rtos\include;.\LPC17XX_Lib\Driver\include;.\LPC17XX_Lib\CMSIS\CoreSupport;.\LPC17XX_Lib\CMSIS\DeviceSupport
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group app
    ./app/: application.c platform.c startup.c platform.h trace.h type.h packet.h packet.c protocol.h global.h global.c parameter.c parameter.h
  group bsp
    ./bsp/: board.h board.c PinDefine.h meter.c meter.h relay.c relay.h switch.c switch.h control.c control.h com_port.h com_port.c 24Cxx.c I2C.c eeprom.c eeprom.h
  group rt-thread
    ./rtos/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group rt-thread-ports
    ./cpuport/arm/cortex-m3/: cpuport.c context_rvds.S
    ./cpuport/arm/common/: backtrace.c div0.c showmem.c
  group LPC17XX_CSP_CMSIS_Device
    ./LPC17XX_Lib/CMSIS/DeviceSupport/startup/arm/: startup_LPC17xx.s
    ./LPC17XX_Lib/CMSIS/DeviceSupport/: system_LPC17xx.c LPC17xx.h system_LPC17xx.h
  group LPC17XX_CSP_CMSIS_Core
    ./LPC17XX_Lib/CMSIS/CoreSupport/: core_cm3.h core_cmFunc.h core_cmInstr.h core_cm3.c
  group LPC17XX_CSP_Driver
    ./LPC17XX_Lib/Driver/source/: debug_frmwrk.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_iap.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c
  group cfg
    ./cfg/: lpc17xx_libcfg.h rtconfig.h
  group dev
    ./dev/: console_uart.h console_uart.c dev_adc.h dev_adc.c dev_relay.h dev_relay.c dev_switch.h dev_switch.c dev_pwm.h dev_pwm.c dev_uart.c dev_uart.h dev_eeprom.c
  group thread
    ./thread/: com_thread.c com_thread.h work_thread.c work_thread.h
